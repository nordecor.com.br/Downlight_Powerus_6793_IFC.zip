Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-05-01T16:28:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 01 16:28:09 2025 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\77b68a31-4533-4d2a-868e-4f337f7d7c36\c8060c32-7819-48f2-a3ab-2724bd69f7c1\ifc * Database version: 5507 * Database creation date: Thu May 01 16:28:08 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu May 01 16:28:09 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 01 16:28:09 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_328410
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 6793, Downlight_Powerus_6793_Nordecor_IFC:6793:328410
In: Nível 1
Type - Material: Metal - Alumínio - Preto, LED, Plástico - Policarbonato - Translúcido
Type - Cotas - Altura da luminária: 48 mm; Comprimento da luminária: 148 mm; Comprimento do nicho: 140 mm; Largura da luminária: 45 mm; Largura do nicho: 37 mm
Type - Dados - Data da atualização: 1/05/2025; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Downlight de embutir com borda, acabamento corpo e lente preta, 5 focos, LED 10W, 4000K 35º; Desenvolvedor: Check BIM; Fabricante: Nordecor; Fixação: Molas; Garantia: 2 Anos; Grau de proteção: IP20; Localização: Camboriú-SC / Brasil; Modelo: 6793; Nome do tipo: 6793; Número OmniClass: 23.80.70.11.14.14; Tipo de imagem: Imagem raster: 6793.png; Título OmniClass: Uplights; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/downlight-led-embutir-powerus-5-leds-35o-10w-4-000k-irc90/
Type - Elétrico - Comentários de voltagem: 85-265; Fator de potência - Luminária: 0.5; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - Luminária: 0 W
Type - Engenharia elétrica - Voltagem - Luminária: 0 V
Type - Estrutural - Peso: 0.295
Type - Fotométricos - Fluxo luminoso: 916 lm; Grau de abertura: 35 deg; IRC (RA): >90; Potência: 10 W; SDMC: <3; Temperatura de cor: 4000 K; UGR: <9
Type - Gráficos - Simbologia: Imagem raster: 6793 2D.png
Type - Materiais e acabamentos - Difusor: Plástico - Policarbonato - Translúcido; Luminária: Metal - Alumínio - Preto
Type - Outros - Categoria: Luminárias; Nome da família: Downlight_Powerus_6793_Nordecor_IFC; Preto: yes
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Pset_DistributionFlowElementCommon - Reference: 6793; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Nordecor
Cotas - Área: 0.0159565 m2; Volume: 0.000191967 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 0 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Downlight_Powerus_6793_Nordecor_IFC: 6793; Família e tipo: Downlight_Powerus_6793_Nordecor_IFC: 6793; ID de tipo: Downlight_Powerus_6793_Nordecor_IFC: 6793; Tipo: Downlight_Powerus_6793_Nordecor_IFC: 6793
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
